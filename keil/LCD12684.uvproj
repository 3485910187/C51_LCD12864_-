# Keil uVision project LCD12684.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: LCD12684 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c 12864.c keyboard.c 18B20.c delay.c
